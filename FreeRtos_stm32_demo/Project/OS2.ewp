# IAR project OS2.ewp, settings and files
configuration OS2 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ..\APP\Inc; ..\Drivers\CMSIS\STM32F4xx\Include; ..\Drivers\gpio; ..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\Drivers\usart; ..\Drivers\sysclk; ..\FreeRTOS\include; ..\FreeRTOS\port\IAR\ARM_CM4F; ..\Drivers\ringqueue; ..\Drivers\debug
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\APP\Inc
  OBJCOPY.OOCOutputFile: OS2.hex
  ILINK.IlinkOutputFile: OS2.out
  ILINK.IlinkIcfFile: D:\GitHub_FreeRtos_Stm32\FreeRTOS-Stm32-Demo\FreeRtos_stm32_demo\Drivers\IAR\stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP/inc
    ../APP/Inc/: app_cfg.h com_types.h common.h device_term.h FreeRTOSConfig.h stm32f4xx_hal_conf.h stm32f4xx_it.h
  group APP/src
    ../APP/Src/: app.c device_term.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group APP/test
    ../APP/test/: key_test.c key_test.h led_test.c led_test.h
  group Drivers
    ./: startup_stm32f407xx.s
  group Drivers/at24c02
    ../Drivers/at24c02/: at24c02.c at24c02.h
  group Drivers/CMSIS
    ../Drivers/CMSIS/STM32F4xx/Source/: system_stm32f4xx.c
  group Drivers/debug
    ../Drivers/debug/: debug.c debug.h
  group Drivers/gpio
    ../Drivers/gpio/: gpio.c gpio.h
  group Drivers/ringqueue
    ../Drivers/ringqueue/: ring_queue.c ring_queue.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/sysclk
    ../Drivers/sysclk/: sysclk.c sysclk.h
  group Drivers/usart
    ../Drivers/usart/: usart.c usart.h
  group Drivers/w25q128
    ../Drivers/w25q128/: w25q128.c w25q128.h
  group FreeRTOS
    ../FreeRTOS/port/IAR/ARM_CM4F/: portasm.s
  group FreeRTOS/port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/IAR/ARM_CM4F/: port.c
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
